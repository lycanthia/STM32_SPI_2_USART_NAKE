# Keil uVision project Fertile_stm.uvproj, settings and files
target Fertile_stm (ARM-ADS)
  device: STM32F101C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x200027FF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Fertile_stm +hex
  c flags: Optim=1 oTime=1 OneElfS=1 wLevel=1
  c define: VECT_TAB_FLASH,STM32F10X_LD, USE_STDPERIPH_DRIVER
  c include: ..\library\inc;..\os;..\user
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group Boot&Arch
    ../user/Arch/: Exception.c stm32f10x_it.c stm32f10x_target.c cortexm3_macro.s stm32f10x_hd.s startup_stm32f10x_ld.s
  group library
    ../library/src/: stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim1.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c stm32f10x_fsmc.c
  group Driver
    ../user/Driver/: gpio.c flash.c
  group user
    ../user/: main.c
  group Tasks
    ../user/Task/: mainloop.c spi.c uart.c
  group config
    ../user/Cfg/: config.h stm32f10x_conf.h Version.h
target SRAM (ARM-ADS)
  device: STM32F101C8 STMicroelectronics
  cpu: as above
  output: Fertile_stm +hex
  c flags: Optim=1 oTime=1 OneElfS=1 wLevel=1
  c define: VECT_TAB_FLASH,STM32F10X_LD, USE_STDPERIPH_DRIVER
  c include: ..\library\inc;..\os;..\user
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2800
